# CLONE DM800SE
SRC_URI = " https://jack2015.github.io/files/dreambox-dvb-modules-dm800se-3.2-dm800se-20151201.tar.bz2;name=modules \
	file://modules \
"
SRC_URI[modules.md5sum] = "36c8b8d23cd80460b92eb76b88fb1a25"
SRC_URI[modules.sha256sum] = "71a3b3277d29f57e4949ccd9eed0a1bb18e83189fa184e417f8021a95a0aa812"

