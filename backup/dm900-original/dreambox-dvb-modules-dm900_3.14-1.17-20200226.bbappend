COMPATIBLE_MACHINE = "^(dm900)$"

MD5SUM = "${@d.getVarFlag('SRC_URI', 'dm900.md5sum', True)}"
