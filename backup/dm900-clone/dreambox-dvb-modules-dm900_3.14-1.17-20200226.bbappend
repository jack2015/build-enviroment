KV = "3.14-1.17"
DRIVERDATE = "20200226"

SRC_URI[md5sum] = "5136e1c8c29ce53885ab40fd4f07aa8c"
SRC_URI[sha256sum] = "0b8af55570b382444330c1818722a92af6be372f5b25928ab9c45562d0a3f883"
SRC_URI = "https://jack2015.github.io/files/dreambox-dvb-modules_3.14-1.17-dm900-20190830_dm900.tar.xz"
S = "${WORKDIR}/dreambox-dvb-modules_3.14-1.17-dm900-20190830_dm900"
COMPATIBLE_MACHINE = "^(dm900)$"





